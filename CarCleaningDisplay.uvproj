# Keil uVision project CarCleaningDisplay.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Mini54FDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: CarCleaningDisplay +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS;.\Mini51Series\Include;.\Library\inc;..\CarCleaningDisplay
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Mini51Series/Source/: system_Mini51Series.c
    ./Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ./: main.c
  group Application
    ./Application/: application_main.c
  group Library
    ./Library/src/: sys.c clk.c gpio.c uart.c
